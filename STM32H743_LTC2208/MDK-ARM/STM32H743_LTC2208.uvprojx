# Keil uVision project STM32H743_LTC2208.uvprojx, settings and files
target STM32H743_LTC2208 (6230000::V6.23::ARMCLANG)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x24000000-0x2407FFFF) IRAM2(0x20000000-0x2001FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: STM32H743_LTC2208 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_PWR_LDO_SUPPLY,USE_HAL_DRIVER,STM32H743xx
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;./STM32H743_LTC2208;../BSP;../DSP;../Modules
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x24000000 size 0x80000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c spi.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_dac.c stm32h7xx_hal_dac_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_nand.c stm32h7xx_hal_qspi.c stm32h7xx_hal_sdram.c stm32h7xx_ll_fmc.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Modules
    ../Modules/: Modules_Header.h ad9910.c ad9910.h ad9910_app.c ad9910_app.h ADS8363.c ADS8363.h ads8363_app.c ads8363_app.h ADS8688.c ADS8688.h ads8688_app.c ads8688_app.h ad5687.c ad5687.h ad5687_app.c ad5687_app.h ad603.c ad603.h dac8831.c dac8831.h dac8831_app.c dac8831_app.h fpga_link.c fpga_link.h ad9708.c ad9708.h ad9708_app.c ad9708_app.h ltc2208.c ltc2208.h ltc2208_app.c ltc2208_app.h fpga_promax.c fpga_promax.h fpga_promax_link.c fpga_promax_link.h fpga_promax_link_map.h PE4302.c PE4302.h
  group BSP
    ../BSP/: BSP_Header.h signal_adc.h signal_adc_ltc2208.c g_contest_app.c g_contest_app.h g_contest_cli.c g_contest_cli.h g_tjc_ui.c g_tjc_ui.h Serial_Buffer.c Serial_Buffer.h bsp_storage.c bsp_storage.h bsp_sdram.c bsp_sdram.h bsp_nand.c bsp_nand.h bsp_qspi_flash.c bsp_qspi_flash.h storage_test.c storage_test.h
    ../Core/Inc/: g_contest_config.h
  group DSP
    ../DSP/: DSP_Header.h FFT.c FFT.h Filter.c Filter.h FilterEx.c FilterEx.h Adaptive.c Adaptive.h Correlate.c Correlate.h Demod.c Demod.h Fit.c Fit.h IQ.c IQ.h SoftPll.c SoftPll.h Measure.c Measure.h DSP_ProMax.c DSP_ProMax.h ModelFit.c ModelFit.h periodic_analyzer.c periodic_analyzer.h
software components: CMSIS:CORE 6.2.0, CMSIS:DSP 1.16.2

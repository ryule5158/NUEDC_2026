# Keil uVision project TI_MSPM0G3507.uvprojx, settings and files
target TI_MSPM0G3507 (6230000::V6.23::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: TI_MSPM0G3507 +hex
  BeforeMake: powershell.exe -NoProfile -ExecutionPolicy Bypass -File "$P..\generate_sysconfig.ps1"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__
  c include: ../SysConfig/Generated,../Board,../Port,../Inc,../BSP,../DSP,../Modules,../third_party/mspm0-sdk-min/source/third_party/CMSIS/Core/Include,../third_party/mspm0-sdk-min/source
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: ./mspm0g3507.sct
  link misc: ../third_party/mspm0-sdk-min/source/ti/driverlib/lib/keil/m0p/mspm0g1x0x_g3x0x/driverlib.a
  group Application
    ../Src/: main.c
  group TI SysConfig
    ../SysConfig/: MSP_LITO_G3507_Board.syscfg
    ../SysConfig/Generated/: ti_msp_dl_config.c ti_msp_dl_config.h
  group Port Compatibility
    ../Port/: adc.h arm_const_structs.h arm_math.h arm_math_lite.c gpio.h main.h nuedc_hal_compat.c fpga_link_ti.c fpga_promax_link_ti.c nuedc_retarget.c spi.h stm32h7xx_hal.h tim.h usart.h
  group BSP
    ../BSP/: adc_app.c adc_app.h BSP_Header.h Serial_Buffer.c Serial_Buffer.h
  group DSP
    ../DSP/: Adaptive.c Adaptive.h ADC_FFT.c ADC_FFT.h Correlate.c Correlate.h Demod.c Demod.h DSP_Header.h FFT.c FFT.h Filter.c Filter.h Fit.c Fit.h IQ.c IQ.h Measure.c Measure.h ModelFit.c ModelFit.h SoftPll.c SoftPll.h
  group Modules
    ../Modules/: ad5687.c ad5687.h ad5687_app.c ad5687_app.h ad603.c ad603.h ad9910.c ad9910.h ad9910_app.c ad9910_app.h ADS8363.c ADS8363.h ads8363_app.c ads8363_app.h dac8831.c dac8831.h dac8831_app.c dac8831_app.h Modules_Header.h ad9708.c ad9708.h ad9708_app.c ad9708_app.h ad9280.c ad9280.h ad9280_app.c ad9280_app.h fpga_link.h fpga_promax.c fpga_promax.h fpga_promax_link.h fpga_promax_link_map.h
  group Startup
    ./: startup_mspm0g350x_uvision.s
